# IAR project iar-project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC2538SF53 TexasInstruments CC2538SF53
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CC2538_USE_ALTERNATE_INTERRUPT_MAP; DEBUG
  ICCARM.CCIncludePath2: ../src; ../../../board/openmote-b; ../../../drivers; ../../../drivers/at86rf215; ../../../drivers/bme280; ../../../drivers/opt3001; ../../../freertos/common; ../../../freertos/cortex-m3/iar; ../../../freertos/inc; ../../../platform/inc; ../../../platform/cc2538; ../../../sys/inc; ../../../sys/src; ../../../ti/cc2538/inc; ../../../ti/cc2538/src; ../../../
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ../src
  OBJCOPY.OOCOutputFile: iar-project.srec
  ILINK.IlinkOutputFile: iar-project.out
  ILINK.IlinkAdditionalLibs: ../../../ti/cc2538/libcc2538_iar.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG
  ICCARM.CCIncludePath2: ../src; ../../../board/openmote-b; ../../../drivers; ../../../drivers/at86rf215; ../../../drivers/bme280; ../../../drivers/opt3001; ../../../freertos/common; ../../../freertos/cortex-m3/iar; ../../../freertos/inc; ../../../platform/cc2538; ../../../platform/cc2538/libcc2538/inc; ../../../platform/cc2538/libcc2538/src; ../../../platform/inc; ../../../sys/inc; ../../../sys/src
  ICCARM.CCOptStrategy: 0
  group board/openmote-b
    ../../../board/openmote-b/: BoardImplementation.cpp BoardImplementation.hpp
  group drivers/at86rf215
    ../../../drivers/at86rf215/: At86rf215.cpp At86rf215.hpp At86rf215_conf.cpp At86rf215_conf.h At86rf215_regs.h
  group drivers/bme280
    ../../../drivers/bme280/: Bme280.cpp Bme280.hpp bme280_bosch.cpp bme280_bosch.h bme280_defs.h
  group drivers/opt3001
    ../../../drivers/opt3001/: Opt3001.cpp Opt3001.hpp
  group kernel/freertos/common
    ../../../freertos/common/: croutine.c event_groups.c heap_2.c list.c queue.c stream_buffer.c tasks.c timers.c
  group kernel/freertos/cortex-m3/iar
    ../../../freertos/cortex-m3/iar/: port.c portasm.s portmacro.h
  group kernel/freertos/inc
    ../../../freertos/inc/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group platform/cc2538
    ../../../platform/cc2538/: Aes.cpp Board.cpp cc2538_startup_iar.c Dma.cpp Gpio.cpp GpioAdc.cpp GpioIn.cpp GpioOut.cpp GpioPwm.cpp I2c.cpp InterruptHandler.cpp platform_defines.h platform_includes.h platform_types.h platform_types.hpp Radio.cpp RadioTimer.cpp RandomNumberGenerator.cpp Sha256.cpp SleepTimer.cpp Spi.cpp SysTick.cpp TemperatureSensor.cpp TemperatureSensor.hpp Timer.cpp Uart.cpp Watchdog.cpp
  group platform/inc
    ../../../platform/inc/: Aes.hpp Board.hpp Dma.hpp Gpio.hpp I2c.hpp InterruptHandler.hpp Radio.hpp RadioTimer.hpp RandomNumberGenerator.hpp Sha256.hpp SleepTimer.hpp Spi.hpp SysTick.hpp Timer.hpp Uart.hpp Watchdog.hpp
  group project
    ../src/: cc2538_lowpower.c FreeRTOSConfig.h main.cpp
  group sys/inc
    ../../../sys/inc/: Buffer.hpp Callback.hpp Crc16.hpp CriticalSection.hpp Hdlc.hpp LedBlinker.hpp Logging.hpp Mutex.hpp Rendezvous.hpp Scheduler.hpp Semaphore.hpp Serial.hpp Task.hpp Thread.hpp
  group sys/src
    ../../../sys/src/: Buffer.cpp Crc16.cpp CriticalSection.cpp Hdlc.cpp LedBlinker.cpp Logging.cpp Mutex.cpp Rendezvous.cpp Scheduler.cpp Semaphore.cpp Serial.cpp Task.cpp Thread.cpp
  group ti/cc2538/inc
    ../../../ti/cc2538/inc/: hw_aes.h hw_ana_regs.h hw_cctest.h hw_flash_ctrl.h hw_gpio.h hw_gptimer.h hw_i2cm.h hw_i2cs.h hw_ints.h hw_ioc.h hw_memmap.h hw_nvic.h hw_pka.h hw_rfcore_ffsm.h hw_rfcore_sfr.h hw_rfcore_xreg.h hw_smwdthrosc.h hw_soc_adc.h hw_ssi.h hw_sys_ctrl.h hw_types.h hw_uart.h hw_udma.h hw_udmachctl.h hw_usb.h
  group ti/cc2538/src
    ../../../ti/cc2538/src/: adc.h aes.h bl_commands.h ccm.h cpu.h debug.h ecc_curveinfo.h flash.h gpio.h gptimer.h i2c.h interrupt.h ioc.h pka.h rom.h sha256.h sleepmode.h ssi.h sys_ctrl.h systick.h uart.h udma.h watchdog.h
